<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Relay-Board_2023_Lucy_V1.ewp</path>
  </project>
  <batchBuild />
</workspace>
